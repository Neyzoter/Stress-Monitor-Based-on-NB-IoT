# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32L152xB,USE_HAL_DRIVER
  c misc: --C99
  c include: ..\CORE;..\HALLIB\Inc;..\HALLIB\Inc\Legacy;..\USER;..\BSP\NUCLEO;..\SYSTEM\sys;..\SYSTEM\usart;..\BSP\TIMER;..\BSP\algorithm;..\BSP\BC95_AT;..\BSP;..\BSP\IIC;..\BSP\I2C_OLED;..\BSP\algorithm;..\BSP\BC95;..\BSP\KEY;..\BSP\LOWPOWER;..\BSP\LED;..\BSP\ADC;..\BSP\IO;..\FreeRTOS\include;..\FreeRTOS\portable\Keil\ARM_CM3;..\FreeRTOS\portable\MemMang;..\BSP\MYTASK;..\BSP\IWDG;..\BSP\WWDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ./: main.c stm32l1xx_hal_msp.c stm32l1xx_it.c system_stm32l1xx.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm3.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32l152xb.s
  group HALLIB
    ../HALLIB/Src/: stm32l1xx_hal.c stm32l1xx_hal_gpio.c stm32l1xx_hal_tim.c stm32l1xx_hal_adc.c stm32l1xx_hal_dma.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rtc.c stm32l1xx_hal_cortex.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_usart.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_wwdg.c
  group BSP
    ../BSP/TIMER/: timer.c
    ../BSP/IIC/: myiic.c
    ../BSP/I2C_OLED/: I2C_OLED.c
    ../BSP/algorithm/: algorithm.c
    ../BSP/BC95/: BC95.c
    ../BSP/KEY/: key.c
    ../BSP/LOWPOWER/: lowpower.c
    ../BSP/ADC/: adc.c
    ../BSP/IO/: io.c
    ../BSP/MYTASK/: mytask.c
    ../BSP/IWDG/: iwdg.c
    ../BSP/WWDG/: wwdg.c
    ../BSP/LED/: led.c
    ../BSP/: common.h
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/Keil/ARM_CM3/: port.c
  group README
    ../: README.md
